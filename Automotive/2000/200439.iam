# Autodesk Inventor assembly: 200439
## iProperties
Created: 2008-01
Part Number: 200439
Document SubType Name: Assembly
Designer: jjohnson
Author: jjohnson
