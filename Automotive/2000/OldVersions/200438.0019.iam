# Autodesk Inventor assembly: 200438
## iProperties
Created: 2008-01
Part Number: 200438
Document SubType Name: Assembly
Designer: jjohnson
Author: jjohnson
