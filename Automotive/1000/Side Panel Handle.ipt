# Autodesk Inventor part: Side Panel Handle
## iProperties
Created: 2009-02
Part Number: Side Panel Handle
Document SubType Name: Modeling
Designer: Autodesk
Density: 1 g/cm^3
Author: Autodesk
